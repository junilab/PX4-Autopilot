## src/examples/jhawk/Kconfig
```kconfig
menuconfig EXAMPLES_JHAWK
	bool "jhawk"
	default y
	---help---
		Enable support for Jhawk
```
